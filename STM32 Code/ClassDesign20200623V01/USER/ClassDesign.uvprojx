# Keil uVision project ClassDesign.uvprojx, settings and files
target CodeDesign (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ClassDesign +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
  group HARDWARE
    ../HARDWARE/: OLED.c RC522.c LEDandBuzz.c MAX7219.c Motor.c HDC1080.c Myusart.c Timeout.c
  group USER
    ./: delay.c main.c sys.c usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
